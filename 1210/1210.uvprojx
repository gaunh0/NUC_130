# Keil uVision project 1210.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.9
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: 1210
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\src
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: main.c log.txt user_uart.c user_sys.c buffer.c
    ./src/: uart.c sys.c timer.c
software components: CMSIS:CORE 5.0.0, Device:Startup 3.00.002
